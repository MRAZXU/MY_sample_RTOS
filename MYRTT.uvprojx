# Keil uVision project MYRTT.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: MYRTT
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\User;.\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group user
    ./User/: main.c rtconfig.h
  group rtt_source
    ./rtt_source/: thread.c kservice.c object.c scheduler.c idle.c timer.c clock.c irq.c ipc.c
  group rtt_ports
    ./rtt_ports/: cpuport.c context_rvde.s
  group doc
    ./: readme.txt
  group include
    ./include/: rtdef.h rthw.h rtservice.h rtthread.h
software components: CMSIS:CORE 5.3.0, Device:Startup 1.2.0
